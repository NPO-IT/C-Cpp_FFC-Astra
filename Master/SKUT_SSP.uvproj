# Keil uVision project SKUT_SSP.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SKUT_SSP +hex
  c flags: Optim=1
  c include: ..\..\..\my_lib
  asm include: ..\my_lib
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group SRC
    ./: LPC2300.s main.cpp secondstep.cpp DoubleBufferUshort.cpp softwarecounter.cpp skuttime.cpp fifo_emc.cpp
    ../my_lib/: Flash.cpp
  group lib
    ../my_lib/: crc8.cpp crc16.cpp fastport.cpp pinsel.cpp gpdma.cpp port.cpp rtc.cpp ssp.cpp timer.cpp uart.cpp vic.cpp Flash.cpp
  group info
    ./: ReadMEБЛЕАТЬ!.txt
